# Keil uVision project atk_f103.uvprojx, settings and files
target TOUCH (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  AfterMake: fromelf  --bin -o ..\..\Output\@L.bin  ..\..\Output\%L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\;..\..\User;..\..\Middlewares
  memory RVCT4: ROM 0x20001000 size 0xd000
  memory RVCT9: RAM 0x2000e000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: main.c stm32f1xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_spi.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/TOUCH/: touch.c ctiic.c ft5206.c gt9xxx.c
    ../../Drivers/BSP/IIC/: myiic.c
    ../../Drivers/BSP/24CXX/: 24cxx.c
  group Readme
    ../../: readme.txt
